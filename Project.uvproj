# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Project +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ./src/lib
  link misc: REMOVEUNUSED
  group Source Group 1
    ./src/: main.c
    ./src/src/: gui.c pt6315.c rx8025.c sys.c stc_usb_cdc_8h_xdata.lib i2c.c dht20.c
